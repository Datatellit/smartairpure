# IAR project xlightAirpure.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105; RF24
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; Project\inc; ..\xlightCommon-stm8s\Xlight_lib; ..\xlightCommon-stm8s\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: switch_v2.0.0.hex
  ILINK.IlinkOutputFile: xlightAirpure.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: STM8S105; NDEBUG
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc; $PROJ_DIR$
  group STM8S Library/inc
    ../xlightCommon-stm8s/STM8S_StdPeriph_Driver/inc/: stm8s_adc1.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_uart2.h stm8s_wwdg.h
  group STM8S Library/src
    ../xlightCommon-stm8s/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart2.c stm8s_wwdg.c
  group User/Common
    ../xlightCommon-stm8s/Xlight_lib/: debugDefine.h FlashDataStorage.c FlashDataStorage.h MyMessage.h RelayPublicDefine.h rf24l01.c rf24l01.h timer_2.c timer_2.h Uart2Dev.c Uart2Dev.h wwdg.c wwdg.h xliNodeConfig.h
  group User/inc
    Project/inc/: _global.h airpure_mia.h ProtocolParser.h timer_4.h
  group User/src
    Project/src/: airpure_mia.c main.c ProtocolParser.c timer_4.c
